# Keil uVision project inputBasic.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: inputBasic
  c flags: Optimize=8 SizeSpeed=1
  group New Group
    ./: Messi.C
